Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: /dev/null
Time: 2026-11-08T13:05:21+08:00
Written by: IfcOpenShell 0.8.5
Made in: IfcOpenShell 0.8.5
Authorization: Nobody

# IfcSpace, Room
In: Storey
BSA_DesignInputs - Source: Explicit synthetic geometry, water properties and excess K assumptions for a numerical demonstration; no manufacturer or code applicability.; GeometryScope: axis-aligned envelopes, straight circular walls and explicit 90-degree elbows

# IfcDistributionPort (6)
BSA_DesignInputs - Source: Explicit synthetic geometry, water properties and excess K assumptions for a numerical demonstration; no manufacturer or code applicability.
Name | FlowDirection
3 x in | SINK
3 x out | SOURCE

# IfcDistributionSystem, WATER
PredefinedType: DOMESTICCOLDWATER
BSA_DesignInputs - Source: Explicit synthetic geometry, water properties and excess K assumptions for a numerical demonstration; no manufacturer or code applicability.

# IfcPipeFitting, BEND
In: Room
PredefinedType: BEND; Group: WATER
BSA_DesignInputs - Source: Explicit synthetic geometry, water properties and excess K assumptions for a numerical demonstration; no manufacturer or code applicability.; GeometryScope: axis-aligned envelopes, straight circular walls and explicit 90-degree elbows; InputID: BEND; BodyShape: circular 90-degree elbow wall; InternalDiameter_m: 0.08; OutsideDiameter_m: 0.1; CenterlineRadius_m: 0.3; LocalLossCoefficient: 0.4; LocalLossBasis: excess over centreline Darcy friction

# IfcPipeSegment (2)
In: Room
BSA_DesignInputs - Source: Explicit synthetic geometry, water properties and excess K assumptions for a numerical demonstration; no manufacturer or code applicability.; GeometryScope: axis-aligned envelopes, straight circular walls and explicit 90-degree elbows; BodyShape: straight circular wall; InternalDiameter_m: 0.08; OutsideDiameter_m: 0.1; LocalLossCoefficient: 0; LocalLossBasis: excess over centreline Darcy friction
Group: WATER
Name | InputID
IN | IN
OUT | OUT
