Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: /dev/null
Time: 2026-11-09T08:54:22+08:00
Written by: IfcOpenShell 0.8.5
Made in: IfcOpenShell 0.8.5
Authorization: Nobody

# IfcSpace, ServiceShaft
In: Storey
BSA_DesignInputs - Source: Explicit synthetic IFC route fixture: 5 m vertical route, 32 mm bore, 40 mm outside diameter, 1 L/s tank outflow target. Product, pump/tank shape and code suitability not established.; GeometryScope: axis-aligned envelopes and explicit straight circular walls

# IfcDistributionPort (6)
BSA_DesignInputs - Source: Explicit synthetic IFC route fixture: 5 m vertical route, 32 mm bore, 40 mm outside diameter, 1 L/s tank outflow target. Product, pump/tank shape and code suitability not established.
Name | FlowDirection
3 x out | SOURCE
3 x in | SINK

# IfcDistributionSystem, COLD-WATER
PredefinedType: DOMESTICCOLDWATER
BSA_DesignInputs - Source: Explicit synthetic IFC route fixture: 5 m vertical route, 32 mm bore, 40 mm outside diameter, 1 L/s tank outflow target. Product, pump/tank shape and code suitability not established.

# IfcPipeSegment (2)
In: ServiceShaft
BSA_DesignInputs - Source: Explicit synthetic IFC route fixture: 5 m vertical route, 32 mm bore, 40 mm outside diameter, 1 L/s tank outflow target. Product, pump/tank shape and code suitability not established.; GeometryScope: axis-aligned envelopes and explicit straight circular walls; BodyShape: straight circular wall; InternalDiameter_m: 0.032; OutsideDiameter_m: 0.04
Group: COLD-WATER
Name | InputID
RISE-LOW | RISE-LOW
RISE-HIGH | RISE-HIGH

# IfcPump, BOOSTER
In: ServiceShaft
BSA_DesignInputs - Source: Explicit synthetic IFC route fixture: 5 m vertical route, 32 mm bore, 40 mm outside diameter, 1 L/s tank outflow target. Product, pump/tank shape and code suitability not established.; GeometryScope: axis-aligned envelopes and explicit straight circular walls; InputID: BOOSTER; BodyShape: bounding envelope
Group: COLD-WATER

# IfcSanitaryTerminal, OUTLET
In: ServiceShaft
BSA_DesignInputs - Source: Explicit synthetic IFC route fixture: 5 m vertical route, 32 mm bore, 40 mm outside diameter, 1 L/s tank outflow target. Product, pump/tank shape and code suitability not established.; GeometryScope: axis-aligned envelopes and explicit straight circular walls; InputID: OUTLET; BodyShape: bounding envelope
Group: COLD-WATER
