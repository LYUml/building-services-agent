Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: /dev/null
Time: 2026-11-09T07:50:14+08:00
Written by: IfcOpenShell 0.8.5
Made in: IfcOpenShell 0.8.5
Authorization: Nobody

# IfcSpace, Plant
In: Storey
BSA_DesignInputs - Source: Synthetic axis-aligned closed circulation, 65 mm bore and 80 mm OD; independently declared 1/2 m routes at z=1 m. Coincident zero-loss nodes and aggregate K are explicit test assumptions. No actual product, clash or design acceptance.; GeometryScope: axis-aligned envelopes and explicit straight circular walls

# IfcDistributionPort (20)
BSA_DesignInputs - Source: Synthetic axis-aligned closed circulation, 65 mm bore and 80 mm OD; independently declared 1/2 m routes at z=1 m. Coincident zero-loss nodes and aggregate K are explicit test assumptions. No actual product, clash or design acceptance.
Name | FlowDirection
4 x in | SOURCEANDSINK
4 x out | SOURCEANDSINK
in | SINK
out | SOURCE
2 x REFERENCE | SOURCEANDSINK
2 x RETURN | SOURCEANDSINK
pump | SOURCE
2 x OUTBOUND | SOURCEANDSINK
pump | SINK
2 x CROSS | SOURCEANDSINK

# IfcDistributionSystem, WATER
PredefinedType: CHILLEDWATER
BSA_DesignInputs - Source: Synthetic axis-aligned closed circulation, 65 mm bore and 80 mm OD; independently declared 1/2 m routes at z=1 m. Coincident zero-loss nodes and aggregate K are explicit test assumptions. No actual product, clash or design acceptance.

# IfcPipeSegment (4)
In: Plant
BSA_DesignInputs - Source: Synthetic axis-aligned closed circulation, 65 mm bore and 80 mm OD; independently declared 1/2 m routes at z=1 m. Coincident zero-loss nodes and aggregate K are explicit test assumptions. No actual product, clash or design acceptance.; GeometryScope: axis-aligned envelopes and explicit straight circular walls; BodyShape: straight circular wall; InternalDiameter_m: 0.065; OutsideDiameter_m: 0.08
Group: WATER
Name | InputID
REFERENCE | REFERENCE
OUTBOUND | OUTBOUND
CROSS | CROSS
RETURN | RETURN

# IfcPump, PUMP
In: Plant
BSA_DesignInputs - Source: Synthetic axis-aligned closed circulation, 65 mm bore and 80 mm OD; independently declared 1/2 m routes at z=1 m. Coincident zero-loss nodes and aggregate K are explicit test assumptions. No actual product, clash or design acceptance.; GeometryScope: axis-aligned envelopes and explicit straight circular walls; InputID: PUMP; BodyShape: bounding envelope
BSA_ScreenedPumpCurve - CandidateId: supported-example; HeadCurve_m3_s_m: [[0,10],[0.005,1]]; Source: Synthetic two-point demonstration curve; no real pump applicability; ScreeningReportSHA256: e47f661a773af231ca33942b22d9ff4052d572848216dc23ac52e50a65bbc16d; Scope: Screened hydraulic curve only; physical product, motor, efficiency and NPSH not established
Group: WATER

# IfcUnitaryEquipment (5)
In: Plant
BSA_DesignInputs - Source: Synthetic axis-aligned closed circulation, 65 mm bore and 80 mm OD; independently declared 1/2 m routes at z=1 m. Coincident zero-loss nodes and aggregate K are explicit test assumptions. No actual product, clash or design acceptance.; GeometryScope: axis-aligned envelopes and explicit straight circular walls; BodyShape: bounding envelope
Group: WATER
Name | InputID
N_REF | N_REF
N_SUCTION | N_SUCTION
N_SUPPLY | N_SUPPLY
N_A | N_A
N_B | N_B
