Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: /dev/null
Time: 2026-11-09T07:17:24+08:00
Written by: IfcOpenShell 0.8.5
Made in: IfcOpenShell 0.8.5
Authorization: Nobody

# IfcSpace, ServiceShaft
In: Storey
BSA_DesignInputs - Source: Explicit synthetic test inputs: 5 m vertical rise, prescribed 1 L/s water flow, 998 kg/m3 and 0.001 Pa s; 180 kPa supply total pressure, 100 kPa required outlet total pressure, K=3, 2 m/s target. Not measured, manufacturer or regulatory data.; GeometryScope: axis-aligned envelopes and explicit straight circular walls

# IfcDistributionPort (6)
BSA_DesignInputs - Source: Explicit synthetic test inputs: 5 m vertical rise, prescribed 1 L/s water flow, 998 kg/m3 and 0.001 Pa s; 180 kPa supply total pressure, 100 kPa required outlet total pressure, K=3, 2 m/s target. Not measured, manufacturer or regulatory data.
Name | FlowDirection
3 x out | SOURCE
3 x in | SINK

# IfcDistributionSystem, COLD-WATER
PredefinedType: DOMESTICCOLDWATER
BSA_DesignInputs - Source: Explicit synthetic test inputs: 5 m vertical rise, prescribed 1 L/s water flow, 998 kg/m3 and 0.001 Pa s; 180 kPa supply total pressure, 100 kPa required outlet total pressure, K=3, 2 m/s target. Not measured, manufacturer or regulatory data.

# IfcPipeSegment (2)
In: ServiceShaft
BSA_DesignInputs - Source: Explicit synthetic test inputs: 5 m vertical rise, prescribed 1 L/s water flow, 998 kg/m3 and 0.001 Pa s; 180 kPa supply total pressure, 100 kPa required outlet total pressure, K=3, 2 m/s target. Not measured, manufacturer or regulatory data.; GeometryScope: axis-aligned envelopes and explicit straight circular walls; BodyShape: straight circular wall; InternalDiameter_m: 0.015; OutsideDiameter_m: 0.022
Group: COLD-WATER
Name | InputID
RISE-LOW | RISE-LOW
RISE-HIGH | RISE-HIGH

# IfcPump, BOOSTER
In: ServiceShaft
BSA_DesignInputs - Source: Explicit synthetic test inputs: 5 m vertical rise, prescribed 1 L/s water flow, 998 kg/m3 and 0.001 Pa s; 180 kPa supply total pressure, 100 kPa required outlet total pressure, K=3, 2 m/s target. Not measured, manufacturer or regulatory data.; GeometryScope: axis-aligned envelopes and explicit straight circular walls; InputID: BOOSTER; BodyShape: bounding envelope
Group: COLD-WATER

# IfcSanitaryTerminal, OUTLET
In: ServiceShaft
BSA_DesignInputs - Source: Explicit synthetic test inputs: 5 m vertical rise, prescribed 1 L/s water flow, 998 kg/m3 and 0.001 Pa s; 180 kPa supply total pressure, 100 kPa required outlet total pressure, K=3, 2 m/s target. Not measured, manufacturer or regulatory data.; GeometryScope: axis-aligned envelopes and explicit straight circular walls; InputID: OUTLET; BodyShape: bounding envelope
Group: COLD-WATER
