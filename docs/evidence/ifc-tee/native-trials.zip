Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView]
Time: 2026-11-09T09:36:56
Written by: IfcOpenShell 0.8.5-1c5b825
Made in: IfcOpenShell 0.8.5-1c5b825

# IfcDistributionPort (3)
FlowDirection: SOURCEANDSINK
Name
main-a
main-b
branch

# IfcPipeFitting, SYNTHETIC-TEE
In: Synthetic trial
PredefinedType: JUNCTION
BSA_TeeTrial - Source: Explicit synthetic software geometry fixture; not a manufacturer fitting or installation specification; OuterRadius_m: 0.02; InnerRadius_m: 0.016; MainHalfLength_m: 0.1; BranchLength_m: 0.1; Scope: Synthetic intersecting-cylinder wall; no manufacturer, K-factor or installation acceptance
